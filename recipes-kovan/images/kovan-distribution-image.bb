# Image for assisting in hardware bringup

require kovan-bringup-image.bb

IMAGE_INSTALL += ""
export IMAGE_BASENAME = "kovan-distribution"
